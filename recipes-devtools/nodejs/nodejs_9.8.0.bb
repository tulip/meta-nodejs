require nodejs_9.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=806d0f94e871430f93be37d90e0439b5"

SRC_URI[src.md5sum] = "8643dac96b14c893598ba4eb4e43b86a"
SRC_URI[src.sha256sum] = "e84a1baf8248411d2c875c2f4e519878af3fb62fdfe04f9607cc085e6a0e59d6"

