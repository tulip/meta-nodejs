require nodejs_9.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=901a716fda2eb1c055c623b3bc8407cf"

SRC_URI[src.md5sum] = "c58d810cdc9c9fff8e3212f03e30a1b2"
SRC_URI[src.sha256sum] = "42dc9f4fe1db689284d5e848963a4f9af1f5092a9a167a890ccd88dcd6fd51df"

