require nodejs_8.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=270f7477a1705f7cd3e29d3d4512915d"

SRC_URI[src.md5sum] = "948257cde87c1fe1c0f697347cb57e4b"
SRC_URI[src.sha256sum] = "57ddd302260f77fa6dfe774f97b196828ec7c08aafbbd8def5e527a388d18f2d"

