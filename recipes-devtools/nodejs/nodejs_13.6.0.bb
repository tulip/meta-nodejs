require nodejs_13.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=2aea9cf46d683635190276ab20e13cfe"

SRC_URI[src.md5sum] = "bd339cafceec5ccee1148a9d26653943"
SRC_URI[src.sha256sum] = "c1db19b4cf23b3903ac3048dad44a05397a63854b2a159fedc454eb15650369a"

