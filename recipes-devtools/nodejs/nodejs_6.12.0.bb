require nodejs_6.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=14152103612601231d62308345463670"

SRC_URI[src.md5sum] = "3a45bc42fbc2d046c49fdfb94fbf8732"
SRC_URI[src.sha256sum] = "05d31c82cabca32f2fe15a1a335899467796396efeca8bdcd5b86621fd2ee319"
