require nodejs_10.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=b0267987d0755bce12779a100826ef97"

SRC_URI[src.md5sum] = "ca0b034c0f0c0c6eda6b209ceb587723"
SRC_URI[src.sha256sum] = "b903ba6dc8131b9357e7c5e26967a0f48aa460c708154244a6348d49a7d8ff9a"

