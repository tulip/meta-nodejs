require nodejs_10.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=b0267987d0755bce12779a100826ef97"

SRC_URI[src.md5sum] = "db2fcfb40c4fe4049ad172cf3f99fd2f"
SRC_URI[src.sha256sum] = "88d9c8179bde19e057cd1d8b835b50726e4c94f8418c91472001e212da96d290"

