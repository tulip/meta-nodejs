require nodejs_8.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=14045ee6ae930d784435884f8aa1be0d"

SRC_URI[src.md5sum] = "7482b2523f72000d1b6060c38945026b"
SRC_URI[src.sha256sum] = "32491b7fcc4696b2cdead45c47e52ad16bbed8f78885d32e873952fee0f971e1"

