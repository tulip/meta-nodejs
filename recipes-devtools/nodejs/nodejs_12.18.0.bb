require nodejs_12.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=66c0e33ee51ac51b336ab444705b259e"

SRC_URI[src.md5sum] = "b3ae81d0aeadd348f81911ba49843ebb"
SRC_URI[src.sha256sum] = "a55c36f0cd9898f8bfa5a793a9e656e78d383f643ebec94afa67d084620b2b13"

