require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=d29463feca32ea5977af7b6c7d62c14a"

SRC_URI[src.md5sum] = "652fc03608e00dc9e5688331328ef62f"
SRC_URI[src.sha256sum] = "baf060e5d3abb8fdebb8c2b28c4d8cde05d43acfd9fc687f21f4b7a3ff69745e"

