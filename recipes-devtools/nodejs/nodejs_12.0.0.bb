require nodejs_12.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=2aea9cf46d683635190276ab20e13cfe"

SRC_URI[src.md5sum] = "74bdcc5d80110e385e3876f681656f97"
SRC_URI[src.sha256sum] = "ef7a25d25370a0c618d50ea72f2e78b8777e015160694d7b7cac05188cc0db65"

