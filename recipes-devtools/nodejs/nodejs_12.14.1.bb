require nodejs_12.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=be4d5107c64dc3d7c57e3797e1a0674b"

SRC_URI[src.md5sum] = "7f2fa2f5df2b8179b5b00ec7de361b34"
SRC_URI[src.sha256sum] = "42a7f0777fea8825611cb9250ff927824dba4f7aea854b47d522798acf4bdbc6"

