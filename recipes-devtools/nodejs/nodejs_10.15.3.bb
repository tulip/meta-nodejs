require nodejs_10.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=b0267987d0755bce12779a100826ef97"

SRC_URI[src.md5sum] = "fa0bcf98b918337c0f368bb0674a2489"
SRC_URI[src.sha256sum] = "db460a63d057ac015b75bb6a879fcbe2fefaaf22afa4b6f6445b9db61ce2270d"

