require nodejs_4.inc
require nodejs_iojs.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=f45e9ffb97e64da46d14f462d34a039f"

SRC_URI[src.md5sum] = "05066a1680529b21be926118fe1793c5"
SRC_URI[src.sha256sum] = "f37a92ca7254ecac80f905a5ba5c5ccf8d886c7dab80d84cf6e28af24b1ff680"
