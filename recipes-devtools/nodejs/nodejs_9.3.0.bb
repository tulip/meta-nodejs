require nodejs_9.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=901a716fda2eb1c055c623b3bc8407cf"

SRC_URI[src.md5sum] = "a3bc6ab4a571a38a47951d68a50ba8f2"
SRC_URI[src.sha256sum] = "b7338f2b1588264c9591fef08246d72ceed664eb18f2556692b4679302bbe2a5"

