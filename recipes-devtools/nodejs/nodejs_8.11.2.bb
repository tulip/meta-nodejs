require nodejs_8.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=fde91d5c5bbd1e0389623e1ac018d9e8"

SRC_URI[src.md5sum] = "f1275596bb95568aa4d19028dcb4fd0d"
SRC_URI[src.sha256sum] = "0ac2c4de270caa08b5adcdb3c6bcb8aae3651a37d035d385bc819fbacaf350e6"

